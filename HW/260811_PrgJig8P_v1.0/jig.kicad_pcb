# Repository ryuhunkyu/PrgJig8P

File README.md:

# PrgJig8P
MCU 8Port Programmer Jig 

[260913:기본 기능 설명서]
기본적인 설계내용은 program code에 올려져 있다.
제품의 목적은 embedded 전자회로물을 생산시 각 PCB를 1개씩 Program하는 방식으로 하였는데 
생산업체에서 인력문제 때문에 이 일을 좀 더 빨리 할 수 있는 방법을 제공하여 비용을 절감하려고 하는 것이다. 

지금은 단순히 Program만 빨리 할 수 있으며 다른 기능은 없다. 
8채널인 이유는 보통 PCB Array를 8개 이내에서 하기 때문이며 그 이상은 별도로 다시 만들어야 한다. 
작업자는 단순히 전원을 공급하고 별도 포고핀이 설치된 확장 PCB Array기판을 만들고 
기판 고정장치도 따로 제작해야 한다. 
그것까지 이 프로젝트에 포함되지는 않는다. 그것은 기계파트에서 작업할 일의비중이 더 크다. 

이 제품의 작동은 기본적으로 PC(computer)상에서 작동하는 각종 programing 환경을 
그대로 쓰는데 마우스로 버튼을 클릭하면 Program이 시작되는 점을 이용한다. 

Program Button을 누르면 8개 중에 선택된 하나의 포트로 PC의 program signal을 연결하면 
그대로 선택된 Port에 연결된 PCB의 MCU만 Program되는 것이다. 

기타 나머지 세세한 조작은 소스 코드 안에 scenario section에 설명되어있다. 

이 제품은 program성공/실패를 알지 못한다. 

작업자가 컴퓨터를 보고 판단해서 program을 Stop시켜 다시 할 수도 있지만 
기본적으로 아주 단순한 기능을 제공한다.

## KiCad design HW/260811_PrgJig8P_v1.0/jig.kicad_pcb

Parts:
BZ1: BMX-2705; Buzzer_CUI_CPT-9019S-SMT
C1: 104; C_0603_1608Metric
Con1: Programmer; PinSocket_1x08_P2.54mm_Vertical
Con2: AdaptorJack; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
Con3: AVR_ISP; Connector_2x3
Con4: Mouse; PinHeader_1x02_P2.54mm_Vertical
Con5: ISP; Connector_2x3
Con6: Key; PinHeader_1x02_P2.54mm_Vertical
D1: 1N4148; D_1206_3216Metric
D2: LED; LED_0603_1608Metric
FB1: Bead; L_1206_3216Metric
H1, H2, H3, H4: MountingHole; Hole_4mm
JP1: TG_Volt; PinHeader_2x03_P2.54mm_Vertical
Q4: 2N2222; SOT-23
R5, R6, R8: 101; R_0603_1608Metric
R7: 100; R_0603_1608Metric
SW1, SW2: Push; SW_PUSH-12mm
SW3: Tactile; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
TP1: TestPoint; TestPoint_Pad_2.0x2.0mm
U1: ATmega8A-A; TQFP-32_7x7mm_P0.8mm
U2: AQY280S; SO-4_4.4x4.3mm_P2.54mm

Connections:
+1V8: JP1.5; also elsewhere on the board
+3.3V: JP1.3; also elsewhere on the board
Beep: R6.1, U1.14 ((SS-/OC1B)PB2)
Button: Con6.1, SW1.2 (B), U1.10 ((AIN0)PD6)
CLK: U1.27 (PC4(ADC4/SDA)); also elsewhere on the board
Click1: Con4.1, U2.4
Click2: Con4.2, U2.3
Control: SW2.2 (B), U1.9 ((T1)PD5)
GND: C1.2, Con2.2, Con3.6, Con6.2, D1.2 (A), D2.1 (K), R7.1, SW1.1 (A), SW2.1 (A), SW3.1 (A), U1.3 (GND), U1.5 (GND), U1.21 (GND); also elsewhere on the board
GNDD: Con1.3, Con5.6; also elsewhere on the board
Good: R5.2, U1.7 ((X1)PB6)
Latch: U1.26 (PC3(ADC3)); also elsewhere on the board
MISO: Con3.1, U1.16 ((MISO)PB4)
MOSI: Con3.5, U1.15 ((MOSI/OC2)PB3)
MPG1: Con1.1; also elsewhere on the board
MPG2: Con1.2, Con5.4, JP1.2, JP1.4, JP1.6; also elsewhere on the board
MPG4: Con1.4, Con5.1; also elsewhere on the board
MPG5: Con1.5, Con5.2; also elsewhere on the board
MPG6: Con1.6, Con5.3; also elsewhere on the board
MPG7: Con1.7, Con5.5; also elsewhere on the board
MPG8: Con1.8; also elsewhere on the board
Mouse: U1.13 ((OC1A)PB1), U2.2
unnamed: BZ1.2 (-), Q4.3 (C)
unnamed: Con2.1, FB1.1
unnamed: D2.2 (A), R5.1
unnamed: Q4.1 (B), R6.2
unnamed: Q4.2 (E), R7.2
unnamed: R8.2, U2.1
unnamed: TP1.1 (1_1), U1.11 ((AIN1)PD7)
Reset: Con3.3, SW3.2 (B), U1.29 (PC6(RESET-))
SCK: Con3.2, U1.17 ((Sck)PB5)
SDI: U1.28 (PC5(ADC5/SCL)); also elsewhere on the board
Select1: U1.2 ((Xck/T0)PD4); also elsewhere on the board
Select2: U1.1 ((INT1)PD3); also elsewhere on the board
Select3: U1.32 ((INT0)PD2); also elsewhere on the board
Select4: U1.31 ((TxD)PD1); also elsewhere on the board
Select5: U1.30 ((RxD)PD0); also elsewhere on the board
Select6: U1.25 (PC2(ADC2)); also elsewhere on the board
Select7: U1.24 (PC1(ADC1)); also elsewhere on the board
Select8: U1.23 (PC0(ADC0)); also elsewhere on the board
VDC: FB1.2; also elsewhere on the board
VDD: BZ1.1 (+), C1.1, Con3.4, D1.1 (K), JP1.1, R8.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC); also elsewhere on the board

Notes on the sheet:
12x12 size
Cap Switch
12v
6x6 size
AQY214S

Parts:
C8, C33: 104; C_0603_1608Metric
D4, D6, D8, D10, D12, D14, D16, D18, D19, D20, D21: LED; LED_0603_1608Metric
J1: 4201ASR-3; ELD_426XXXX
Q1, Q2, Q3: 2N2222; SOT-23
R1: 102; R_0603_1608Metric
R2, R3, R4: 472; R_0603_1608Metric
U6: TLC5925; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
/Display/Digit1: J1.10, Q1.2 (E)
/Display/Digit2: J1.5, Q2.2 (E)
/Display/FND_A: D4.1 (K), J1.7, U6.5 (Out0)
/Display/FND_B: D6.1 (K), J1.6, U6.6 (Out1)
/Display/FND_C: D8.1 (K), J1.4, U6.7 (Out2)
/Display/FND_D: D10.1 (K), J1.1, U6.8 (Out3)
/Display/FND_DP: D18.1 (K), J1.2, U6.12 (Out7)
/Display/FND_Dig1: Q1.1 (B), R2.2, U6.13 (Out8)
/Display/FND_Dig2: Q2.1 (B), R3.2, U6.14 (Out9)
/Display/FND_E: D12.1 (K), J1.3, U6.9 (Out4)
/Display/FND_F: D14.1 (K), J1.8, U6.10 (Out5)
/Display/FND_G: D16.1 (K), J1.9, U6.11 (Out6)
/Display/LEDSelect: D4.2 (A), D6.2 (A), D8.2 (A), D10.2 (A), D12.2 (A), D14.2 (A), D16.2 (A), D18.2 (A), Q3.2 (E)
/Display/LED_Sel: Q3.1 (B), R4.2, U6.17 (Out12)
/Display/PrgMode: D19.1 (K), U6.18 (Out13)
/Display/SetTime: D21.1 (K), U6.20 (Out15)
/Display/StopMove: D20.1 (K), U6.19 (Out14)
CLK: U6.3 (Clk); also elsewhere on the board
GND: C8.1, C33.2, R1.1, U6.1 (GND), U6.21 (OE); also elsewhere on the board
Latch: U6.4 (LE); also elsewhere on the board
unnamed: R1.2, U6.23 (RExt)
unnamed: C8.2, U6.22 (SDO)
SDI: U6.2 (SDI); also elsewhere on the board
VDD: C33.1, D19.2 (A), D20.2 (A), D21.2 (A), Q1.3 (C), Q2.3 (C), Q3.3 (C), R2.1, R3.1, R4.1, U6.24 (VDD); also elsewhere on the board

Notes on the sheet:
uDXX-204DA AnodeCommon

Parts:
Con11, Con12, Con13, Con14, Con15, Con16, Con17, Con18: Port; PinSocket_1x08_P2.54mm_Vertical

Connections:
/AnalogSwitch/SPG11: Con11.1; also elsewhere on the board
/AnalogSwitch/SPG12: Con11.2; also elsewhere on the board
/AnalogSwitch/SPG14: Con11.4; also elsewhere on the board
/AnalogSwitch/SPG15: Con11.5; also elsewhere on the board
/AnalogSwitch/SPG16: Con11.6; also elsewhere on the board
/AnalogSwitch/SPG17: Con11.7; also elsewhere on the board
/AnalogSwitch/SPG18: Con11.8; also elsewhere on the board
/AnalogSwitch/SPG21: Con12.1; also elsewhere on the board
/AnalogSwitch/SPG22: Con12.2; also elsewhere on the board
/AnalogSwitch/SPG24: Con12.4; also elsewhere on the board
/AnalogSwitch/SPG25: Con12.5; also elsewhere on the board
/AnalogSwitch/SPG26: Con12.6; also elsewhere on the board
/AnalogSwitch/SPG27: Con12.7; also elsewhere on the board
/AnalogSwitch/SPG28: Con12.8; also elsewhere on the board
/AnalogSwitch/SPG31: Con13.1; also elsewhere on the board
/AnalogSwitch/SPG32: Con13.2; also elsewhere on the board
/AnalogSwitch/SPG34: Con13.4; also elsewhere on the board
/AnalogSwitch/SPG35: Con13.5; also elsewhere on the board
/AnalogSwitch/SPG36: Con13.6; also elsewhere on the board
/AnalogSwitch/SPG37: Con13.7; also elsewhere on the board
/AnalogSwitch/SPG38: Con13.8; also elsewhere on the board
/AnalogSwitch/SPG41: Con14.1; also elsewhere on the board
/AnalogSwitch/SPG42: Con14.2; also elsewhere on the board
/AnalogSwitch/SPG44: Con14.4; also elsewhere on the board
/AnalogSwitch/SPG45: Con14.5; also elsewhere on the board
/AnalogSwitch/SPG46: Con14.6; also elsewhere on the board
/AnalogSwitch/SPG47: Con14.7; also elsewhere on the board
/AnalogSwitch/SPG48: Con14.8; also elsewhere on the board
/AnalogSwitch/SPG51: Con15.1; also elsewhere on the board
/AnalogSwitch/SPG52: Con15.2; also elsewhere on the board
/AnalogSwitch/SPG54: Con15.4; also elsewhere on the board
/AnalogSwitch/SPG55: Con15.5; also elsewhere on the board
/AnalogSwitch/SPG56: Con15.6; also elsewhere on the board
/AnalogSwitch/SPG57: Con15.7; also elsewhere on the board
/AnalogSwitch/SPG58: Con15.8; also elsewhere on the board
/AnalogSwitch/SPG61: Con16.1; also elsewhere on the board
/AnalogSwitch/SPG62: Con16.2; also elsewhere on the board
/AnalogSwitch/SPG64: Con16.4; also elsewhere on the board
/AnalogSwitch/SPG65: Con16.5; also elsewhere on the board
/AnalogSwitch/SPG66: Con16.6; also elsewhere on the board
/AnalogSwitch/SPG67: Con16.7; also elsewhere on the board
/AnalogSwitch/SPG68: Con16.8; also elsewhere on the board
/AnalogSwitch/SPG71: Con17.1; also elsewhere on the board
/AnalogSwitch/SPG72: Con17.2; also elsewhere on the board
/AnalogSwitch/SPG74: Con17.4; also elsewhere on the board
/AnalogSwitch/SPG75: Con17.5; also elsewhere on the board
/AnalogSwitch/SPG76: Con17.6; also elsewhere on the board
/AnalogSwitch/SPG77: Con17.7; also elsewhere on the board
/AnalogSwitch/SPG78: Con17.8; also elsewhere on the board
/AnalogSwitch/SPG81: Con18.1; also elsewhere on the board
/AnalogSwitch/SPG82: Con18.2; also elsewhere on the board
/AnalogSwitch/SPG84: Con18.4; also elsewhere on the board
/AnalogSwitch/SPG85: Con18.5; also elsewhere on the board
/AnalogSwitch/SPG86: Con18.6; also elsewhere on the board
/AnalogSwitch/SPG87: Con18.7; also elsewhere on the board
/AnalogSwitch/SPG88: Con18.8; also elsewhere on the board
GNDD: Con11.3, Con12.3, Con13.3, Con14.3, Con15.3, Con16.3, Con17.3, Con18.3; also elsewhere on the board

Notes on the sheet:
260810:Part Test결과 이상없음. AQY214S, FSA1259: ISP, ICSP
AVR UPDI Mode에서 DAT에 12v를 인가해야 할 경우 불가능함.
AnalogSwitch: 4066,dg411,TC4W66, DG201B
1:TVPP,Reset,MCLR 2:VDD,VTG 3:GND 4:DAT,TDO,SWO,MISO 5:CLK,TCK,SWCLK,SCK 6:TAUX,RESET,CLK 7:TDI,MOSI 8:TMS,SWDIO

Parts:
C2, C3, C4, C5, C6, C7: 100uF; C_1206_3216Metric
U3: L7805; TO-252-2
U4: LM1117S-3.3; TO-252-2
U5: LM1117MP-1.8; SOT-223-3_TabPin2

Connections:
+1V8: C7.1, U5.2 (VO); also elsewhere on the board
+3.3V: C6.1, U4.2 (VO); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, U3.2 (GND), U4.1 (GND), U5.1 (GND); also elsewhere on the board
VDC: C2.1, U3.1 (IN); also elsewhere on the board
VDD: C3.1, C4.1, C5.1, U3.3 (OUT), U4.3 (VI), U5.3 (VI); also elsewhere on the board

Parts:
C9, C10, C11: 104; C_0603_1608Metric
Q5: Q_NMOS_GSD; SOT-23-3
R9: 101; R_0603_1608Metric
R11: 103; R_0603_1608Metric
R12: 472; R_0603_1608Metric
U7: AQY214S; SO-4_4.4x4.3mm_P2.54mm
U9, U10, U11: FSA1259; VSSOP-8_2.3x2mm_P0.5mm

Connections:
/AnalogSwitch/PRGPack1/Sel: Q5.3 (D), R12.1, U9.3, U9.7, U10.3, U10.7, U11.3, U11.7
/AnalogSwitch/SPG11: U7.3; also elsewhere on the board
/AnalogSwitch/SPG12: U11.2; also elsewhere on the board
/AnalogSwitch/SPG14: U9.2; also elsewhere on the board
/AnalogSwitch/SPG15: U9.6; also elsewhere on the board
/AnalogSwitch/SPG16: U10.2; also elsewhere on the board
/AnalogSwitch/SPG17: U10.6; also elsewhere on the board
/AnalogSwitch/SPG18: U11.6; also elsewhere on the board
GND: C9.2, C10.2, C11.2, Q5.2 (S), U9.4 (GND), U10.4 (GND), U11.4 (GND); also elsewhere on the board
MPG1: U7.4; also elsewhere on the board
MPG2: U11.1; also elsewhere on the board
MPG4: U9.1; also elsewhere on the board
MPG5: U9.5; also elsewhere on the board
MPG6: U10.1; also elsewhere on the board
MPG7: U10.5; also elsewhere on the board
MPG8: U11.5; also elsewhere on the board
unnamed: Q5.1 (G), R11.2
unnamed: R9.2, U7.1
Select1: R11.1, U7.2; also elsewhere on the board
VDD: C9.1, C10.1, C11.1, R9.1, R12.2, U9.8 (VCC), U10.8 (VCC), U11.8 (VCC); also elsewhere on the board

Parts of its further copies:
C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32: 104; C_0603_1608Metric
Q6, Q7, Q8, Q9, Q10, Q11, Q12: Q_NMOS_GSD; SOT-23-3
R13, R17, R21, R25, R29, R33, R37: 101; R_0603_1608Metric
R15, R19, R23, R27, R31, R35, R39: 103; R_0603_1608Metric
R16, R20, R24, R28, R32, R36, R40: 472; R_0603_1608Metric
U12, U17, U22, U27, U32, U37, U42: AQY214S; SO-4_4.4x4.3mm_P2.54mm
U14, U15, U16, U19, U20, U21, U24, U25, U26, U29, U30, U31, U34, U35, U36, U39, U40, U41, U44, U45, U46: FSA1259; VSSOP-8_2.3x2mm_P0.5mm

Connections of its further copies:
/AnalogSwitch/PRGPack2/Sel: Q6.3 (D), R16.1, U14.3, U14.7, U15.3, U15.7, U16.3, U16.7
/AnalogSwitch/PRGPack3/Sel: Q7.3 (D), R20.1, U19.3, U19.7, U20.3, U20.7, U21.3, U21.7
/AnalogSwitch/PRGPack4/Sel: Q8.3 (D), R24.1, U24.3, U24.7, U25.3, U25.7, U26.3, U26.7
/AnalogSwitch/PRGPack5/Sel: Q9.3 (D), R28.1, U29.3, U29.7, U30.3, U30.7, U31.3, U31.7
/AnalogSwitch/PRGPack6/Sel: Q10.3 (D), R32.1, U34.3, U34.7, U35.3, U35.7, U36.3, U36.7
/AnalogSwitch/PRGPack7/Sel: Q11.3 (D), R36.1, U39.3, U39.7, U40.3, U40.7, U41.3, U41.7
/AnalogSwitch/PRGPack8/Sel: Q12.3 (D), R40.1, U44.3, U44.7, U45.3, U45.7, U46.3, U46.7
/AnalogSwitch/SPG21: U12.3; also elsewhere on the board
/AnalogSwitch/SPG22: U16.2; also elsewhere on the board
/AnalogSwitch/SPG24: U14.2; also elsewhere on the board
/AnalogSwitch/SPG25: U14.6; also elsewhere on the board
/AnalogSwitch/SPG26: U15.2; also elsewhere on the board
/AnalogSwitch/SPG27: U15.6; also elsewhere on the board
/AnalogSwitch/SPG28: U16.6; also elsewhere on the board
/AnalogSwitch/SPG31: U17.3; also elsewhere on the board
/AnalogSwitch/SPG32: U21.2; also elsewhere on the board
/AnalogSwitch/SPG34: U19.2; also elsewhere on the board
/AnalogSwitch/SPG35: U19.6; also elsewhere on the board
/AnalogSwitch/SPG36: U20.2; also elsewhere on the board
/AnalogSwitch/SPG37: U20.6; also elsewhere on the board
/AnalogSwitch/SPG38: U21.6; also elsewhere on the board
/AnalogSwitch/SPG41: U22.3; also elsewhere on the board
/AnalogSwitch/SPG42: U26.2; also elsewhere on the board
/AnalogSwitch/SPG44: U24.2; also elsewhere on the board
/AnalogSwitch/SPG45: U24.6; also elsewhere on the board
/AnalogSwitch/SPG46: U25.2; also elsewhere on the board
/AnalogSwitch/SPG47: U25.6; also elsewhere on the board
/AnalogSwitch/SPG48: U26.6; also elsewhere on the board
/AnalogSwitch/SPG51: U27.3; also elsewhere on the board
/AnalogSwitch/SPG52: U31.2; also elsewhere on the board
/AnalogSwitch/SPG54: U29.2; also elsewhere on the board
/AnalogSwitch/SPG55: U29.6; also elsewhere on the board
/AnalogSwitch/SPG56: U30.2; also elsewhere on the board
/AnalogSwitch/SPG57: U30.6; also elsewhere on the board
/AnalogSwitch/SPG58: U31.6; also elsewhere on the board
/AnalogSwitch/SPG61: U32.3; also elsewhere on the board
/AnalogSwitch/SPG62: U36.2; also elsewhere on the board
/AnalogSwitch/SPG64: U34.2; also elsewhere on the board
/AnalogSwitch/SPG65: U34.6; also elsewhere on the board
/AnalogSwitch/SPG66: U35.2; also elsewhere on the board
/AnalogSwitch/SPG67: U35.6; also elsewhere on the board
/AnalogSwitch/SPG68: U36.6; also elsewhere on the board
/AnalogSwitch/SPG71: U37.3; also elsewhere on the board
/AnalogSwitch/SPG72: U41.2; also elsewhere on the board
/AnalogSwitch/SPG74: U39.2; also elsewhere on the board
/AnalogSwitch/SPG75: U39.6; also elsewhere on the board
/AnalogSwitch/SPG76: U40.2; also elsewhere on the board
/AnalogSwitch/SPG77: U40.6; also elsewhere on the board
/AnalogSwitch/SPG78: U41.6; also elsewhere on the board
/AnalogSwitch/SPG81: U42.3; also elsewhere on the board
/AnalogSwitch/SPG82: U46.2; also elsewhere on the board
/AnalogSwitch/SPG84: U44.2; also elsewhere on the board
/AnalogSwitch/SPG85: U44.6; also elsewhere on the board
/AnalogSwitch/SPG86: U45.2; also elsewhere on the board
/AnalogSwitch/SPG87: U45.6; also elsewhere on the board
/AnalogSwitch/SPG88: U46.6; also elsewhere on the board
GND: C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), Q12.2 (S), U14.4 (GND), U15.4 (GND), U16.4 (GND), U19.4 (GND), U20.4 (GND), U21.4 (GND), U24.4 (GND), U25.4 (GND), U26.4 (GND), U29.4 (GND), U30.4 (GND), U31.4 (GND), U34.4 (GND), U35.4 (GND), U36.4 (GND), U39.4 (GND), U40.4 (GND), U41.4 (GND), U44.4 (GND), U45.4 (GND), U46.4 (GND); also elsewhere on the board
MPG1: U12.4, U17.4, U22.4, U27.4, U32.4, U37.4, U42.4; also elsewhere on the board
MPG2: U16.1, U21.1, U26.1, U31.1, U36.1, U41.1, U46.1; also elsewhere on the board
MPG4: U14.1, U19.1, U24.1, U29.1, U34.1, U39.1, U44.1; also elsewhere on the board
MPG5: U14.5, U19.5, U24.5, U29.5, U34.5, U39.5, U44.5; also elsewhere on the board
MPG6: U15.1, U20.1, U25.1, U30.1, U35.1, U40.1, U45.1; also elsewhere on the board
MPG7: U15.5, U20.5, U25.5, U30.5, U35.5, U40.5, U45.5; also elsewhere on the board
MPG8: U16.5, U21.5, U26.5, U31.5, U36.5, U41.5, U46.5; also elsewhere on the board
unnamed: Q6.1 (G), R15.2
unnamed: Q7.1 (G), R19.2
unnamed: Q8.1 (G), R23.2
unnamed: Q9.1 (G), R27.2
unnamed: Q10.1 (G), R31.2
unnamed: Q11.1 (G), R35.2
unnamed: Q12.1 (G), R39.2
unnamed: R13.2, U12.1
unnamed: R17.2, U17.1
unnamed: R21.2, U22.1
unnamed: R25.2, U27.1
unnamed: R29.2, U32.1
unnamed: R33.2, U37.1
unnamed: R37.2, U42.1
Select2: R15.1, U12.2; also elsewhere on the board
Select3: R19.1, U17.2; also elsewhere on the board
Select4: R23.1, U22.2; also elsewhere on the board
Select5: R27.1, U27.2; also elsewhere on the board
Select6: R31.1, U32.2; also elsewhere on the board
Select7: R35.1, U37.2; also elsewhere on the board
Select8: R39.1, U42.2; also elsewhere on the board
VDD: C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, R13.1, R16.2, R17.1, R20.2, R21.1, R24.2, R25.1, R28.2, R29.1, R32.2, R33.1, R36.2, R37.1, R40.2, U14.8 (VCC), U15.8 (VCC), U16.8 (VCC), U19.8 (VCC), U20.8 (VCC), U21.8 (VCC), U24.8 (VCC), U25.8 (VCC), U26.8 (VCC), U29.8 (VCC), U30.8 (VCC), U31.8 (VCC), U34.8 (VCC), U35.8 (VCC), U36.8 (VCC), U39.8 (VCC), U40.8 (VCC), U41.8 (VCC), U44.8 (VCC), U45.8 (VCC), U46.8 (VCC); also elsewhere on the board

Notes on the sheet:
ISOM2800DF,VO1400AE,ISOM8600,TLP175A
SN74LVC2G66
MPG2,MPG8을 Switching하는 두개 중 하나만 부착

Board: 2 copper layers, 129.0 x 99.0 mm, 154 parts (0 on the bottom side), 141 nets.

## Code that names these connections

File Firmware/PrgJig8P.X/def.h:

#include <inttypes.h>
#include <math.h>
#include <avr/io.h>
#include <avr/interrupt.h>
#include <avr/sleep.h>
#include <avr/pgmspace.h>
#include <avr/sfr_defs.h>
#include <avr/wdt.h>

#ifndef F_CPU
#define F_CPU				8000000UL		// 8MHz 내부 클럭 사용
#endif

#include <xc.h>
#include <util/delay.h>

#define u8				unsigned char
#define	u16				unsigned int
#define	u32				unsigned long int
#define	i8				char
#define	i16				int
#define	i32				long int
#define	vu8				volatile unsigned char
#define	vu16				volatile unsigned int
#define	vi8				volatile char
#define	vi16				volatile int
                                	
#define	VERSION				0x0090
#define	SYSTEMNAME			"MCU 8Port Programming Jig "
#define	BUILDWEEK			0x2637			// 260910
#define	SERIALNUMBER			0x0001
                                	
#include "PrgJig8P.h"
                                	
//Port Definition               	
#define	PORT_Select5			PD0
#define	PORT_Select4			PD1
#define	PORT_Select3			PD2
#define	PORT_Select2			PD3
#define	PORT_Select1			PD4
#define	PORT_Control			PD5
#define	PORT_Program			PD6
#define	PORT_Test			PD7

#define	PORT_Mouse			PB1
#define	PORT_Beep			PB2
#define	PORT_Good			PB6

#define	PORT_Select8			PC0
#define	PORT_Select7			PC1
#define	PORT_Select6			PC2
#define	PORT_Latch			PC3
#define	PORT_CLK			PC4
#define	PORT_SDI			PC5
                                	
// Register Definition
#define	GOOD_PORT			PORTB
#define	BEEP_PORT			PORTB
#define	MOUSE_PORT			PORTB
#define	PROGRAM_INPORT			PIND
#define	CONTROL_INPORT			PIND
#define	LATCH_PORT			PORTC
#define	TEST_PORT			PORTD
                               	
//<EEPRom Addr> Memory space:0x0000~0x0FFF
#define	EEP_STATE			0x000
#define	EEP_LEVEL			0x002
#define	EEP_COMPARE			0x100

//Constant                      	
#define	LED_ON				1
#define	LED_OFF				0

#define	STATE_IDLE			0
#define	STATE_COMPARE			1
#define	STATE_PERFUSE			2
#define	STATE_REST			3

#define	CHAR_NUMBER			0x00
#define	CHAR_ALPHABET			0x0A
#define	CHAR_DIGIT_ANI			0x24
#define	CHAR_DASH			0x2A
#define	CHAR_TEST			0x2B
#define	CHAR_NONE			0x2C

//Command                       	

//Code define                   	
//#define	sbi(port,bit)		__asm__ __volatile__( "sbi %0, %1" : : "I" (_SFR_IO_ADDR(port)), "I" (bit))
//#define	cbi(port,bit)		__asm__ __volatile__( "cbi %0, %1" : : "I" (_SFR_IO_ADDR(port)), "I" (bit))
//#define	sbis(port,bit)		__asm__ __volatile__("sbis %0, %1" : : "I" (_SFR_IO_ADDR(port)), "I" (bit))

#define sbi(port,bit)			((port) |= (1 << (bit)))
#define cbi(port,bit)			((port) &= ~(1 << (bit)))
#ifndef NOP
#define	NOP				asm( "nop" ::)
#endif

//Microchip 제공 함수 : CPU Clock Delay
#define Delay1us()			__builtin_avr_delay_cycles(8)
#define Delay10us()			__builtin_avr_delay_cycles(80)
#define Delay100us()			__builtin_avr_delay_cycles(800)

//macro
#define	ENABLE_INT0			EIMSK |= (1 << INT0)
#define	DISABLE_INT0			EIMSK &= ~(1 << INT0)
#define	ENABLE_INT1			EIMSK |= (1 << INT1)
#define	DISABLE_INT1			EIMSK &= ~(1 << INT1)
#define	ENABLE_INT2			EIMSK |= (1 << INT2)
#define	DISABLE_INT2			EIMSK &= ~(1 << INT2)

#define	FND_SDI_HIGH			sbi(SDI_PORT, PORT_SDI)
#define	FND_SDI_LOW			cbi(SDI_PORT, PORT_SDI)
#define	FND_CLK_HIGH			sbi(CLK_PORT, PORT_CLK)
#define	FND_CLK_LOW			cbi(CLK_PORT, PORT_CLK)
#define	FND_CLOCK			do{FND_CLK_HIGH;FND_CLK_LOW;} while(0)
#define	FND_LATCH			do{sbi(LATCH_PORT, PORT_Latch); cbi(LATCH_PORT, PORT_Latch);} while(0)

#define	KEY_BUTTON			((~BUTTON_INPORT)&(1<<PORT_Button))
#define	KEY_CONTROL			((~CONTROL_INPORT)&(1<<PORT_Control))

//------------------------------------

extern	u8	MCUState;
extern	u8	OscState;
extern	vu8	Command;
extern	vu8	State;
extern	u8	temp;
extern	u8	Count;
extern	u8	Stamp;
extern	u8	adcChannel;
extern	u16	SerialNumber;

extern	vu8	tToggle;
extern	vu16	Timer;
extern	vu16	TimerDigit;
extern	vi16	SecondCount;
extern	vi16	MiliCount;
extern	vi16	MiliTerm;
extern	vi16	WaitTerm;
extern	vi8	Blink;
extern	vi16	ButtonTime;
extern	vu16	FNDTerm;
extern	vu16	LEDTerm;
extern	vi16	NumbCount;
extern	i16	LEDCount;
extern	vu8	ValveTerm;
extern	vu8	ButtonFlag;
extern	vu8	WindCheckFlag;
extern	vu8	WDFlag;
extern	vu8	ADCFlag;
extern	vu8	TimeOut;

extern	u8	Level;
extern	vi8	PerfuseTerm;
extern	vi8	RestTerm;
extern	u8	ValveCommand;

extern	u8	cfgCompare;
extern	u8	cfgDifference;
extern	u8	cfgPerfuseTerm;
extern	u8	cfgRestTerm;
extern	vi16	ReferenceTemper;

extern	vi16	PowerSum;
extern	vi16	PowerVal;
extern	vi16	WindTemperSum;
extern	vi16	WindTemperVal;
extern	vi16	TemperatureSum;
extern	vi16	TemperatureVal;

extern	i16	ButtonReleaseTerm;
extern	u8	ButtonPressCount;

extern	u8	AS_RecQue[32];
extern	vu8	AS_SendFlag;
extern	vu8	AS_Qwi;
extern	vu8	AS_Qri;

	
